Commit message: Imported upstream version '2.2.9' of 'upstream'

File: turtlebot3_description/urdf/turtlebot3_waffle_pi.urdf (robot description, URDF)
Before this commit: robot turtlebot3_waffle_pi, 11 links, 10 joints
Links:
- removed link ${namespace}mu_link
- added link ${namespace}imu_link
